FILESEXTRAPATHS:prepend := "${THISDIR}/files:"


SRC_URI  += " \
    file://0001-disable-reserved-area-check.patch \
"
